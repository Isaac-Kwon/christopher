# Repository Isaac-Kwon/christopher (continued)

## KiCad design hardware/relay/shifter-board/shifter_board.kicad_pcb (continued)

Schematic: stage_16.kicad_sch, Shifter stage 5: shift 16

Parts:
D501, D502, D503, D504, D505, D506, D507, D508, D509, D510, D511, D512, D513, D514, D515, D516, D517, D518, D519, D520, D521, D522, D523, D524, D525, D526: 1N4148W; D_SOD-123
DL5: LED; LED_0603_1608Metric
K501, K502, K503, K504, K505, K506, K507, K508, K509, K510, K511, K512, K513, K514, K515, K516, K517, K518, K519, K520, K521, K522, K523, K524, K525, K526: G6S-2 24VDC; Relay_DPDT_Omron_G6S-2
R5: 4.7k; R_0603_1608Metric

Connections:
/CTRL4: D501.1 (K), D502.1 (K), D503.1 (K), D504.1 (K), D505.1 (K), D506.1 (K), D507.1 (K), D508.1 (K), D509.1 (K), D510.1 (K), D511.1 (K), D512.1 (K), D513.1 (K), D514.1 (K), D515.1 (K), D516.1 (K), D517.1 (K), D518.1 (K), D519.1 (K), D520.1 (K), D521.1 (K), D522.1 (K), D523.1 (K), D524.1 (K), D525.1 (K), D526.1 (K), K501.1, K502.1, K503.1, K504.1, K505.1, K506.1, K507.1, K508.1, K509.1, K510.1, K511.1, K512.1, K513.1, K514.1, K515.1, K516.1, K517.1, K518.1, K519.1, K520.1, K521.1, K522.1, K523.1, K524.1, K525.1, K526.1, R5.1; also elsewhere on the board
/GND: D501.2 (A), D502.2 (A), D503.2 (A), D504.2 (A), D505.2 (A), D506.2 (A), D507.2 (A), D508.2 (A), D509.2 (A), D510.2 (A), D511.2 (A), D512.2 (A), D513.2 (A), D514.2 (A), D515.2 (A), D516.2 (A), D517.2 (A), D518.2 (A), D519.2 (A), D520.2 (A), D521.2 (A), D522.2 (A), D523.2 (A), D524.2 (A), D525.2 (A), D526.2 (A), DL5.1 (K), K501.12, K502.12, K503.12, K504.12, K505.12, K506.12, K507.12, K508.12, K509.12, K510.12, K511.12, K512.12, K513.12, K514.12, K515.12, K516.12, K517.12, K518.12, K519.12, K520.12, K521.12, K522.12, K523.12, K524.12, K525.12, K526.12; also elsewhere on the board
/O4_A: K501.4; also elsewhere on the board
/O4_B: K502.4; also elsewhere on the board
/O4_C: K503.4; also elsewhere on the board
/O4_D: K504.4; also elsewhere on the board
/O4_E: K505.4; also elsewhere on the board
/O4_F: K506.4; also elsewhere on the board
/O4_G: K507.4; also elsewhere on the board
/O4_H: K508.4; also elsewhere on the board
/O4_I: K509.4; also elsewhere on the board
/O4_J: K510.4; also elsewhere on the board
/O4_K: K511.4; also elsewhere on the board
/O4_L: K512.4; also elsewhere on the board
/O4_M: K513.4; also elsewhere on the board
/O4_N: K514.4; also elsewhere on the board
/O4_O: K515.4; also elsewhere on the board
/O4_P: K516.4; also elsewhere on the board
/O4_Q: K517.4; also elsewhere on the board
/O4_R: K518.4; also elsewhere on the board
/O4_S: K519.4; also elsewhere on the board
/O4_T: K520.4; also elsewhere on the board
/O4_U: K521.4; also elsewhere on the board
/O4_V: K522.4; also elsewhere on the board
/O4_W: K523.4; also elsewhere on the board
/O4_X: K524.4; also elsewhere on the board
/O4_Y: K525.4; also elsewhere on the board
/O4_Z: K526.4; also elsewhere on the board
/OOUT_A: K501.3, K511.5; also elsewhere on the board
/OOUT_B: K502.3, K512.5; also elsewhere on the board
/OOUT_C: K503.3, K513.5; also elsewhere on the board
/OOUT_D: K504.3, K514.5; also elsewhere on the board
/OOUT_E: K505.3, K515.5; also elsewhere on the board
/OOUT_F: K506.3, K516.5; also elsewhere on the board
/OOUT_G: K507.3, K517.5; also elsewhere on the board
/OOUT_H: K508.3, K518.5; also elsewhere on the board
/OOUT_I: K509.3, K519.5; also elsewhere on the board
/OOUT_J: K510.3, K520.5; also elsewhere on the board
/OOUT_K: K511.3, K521.5; also elsewhere on the board
/OOUT_L: K512.3, K522.5; also elsewhere on the board
/OOUT_M: K513.3, K523.5; also elsewhere on the board
/OOUT_N: K514.3, K524.5; also elsewhere on the board
/OOUT_O: K515.3, K525.5; also elsewhere on the board
/OOUT_P: K516.3, K526.5; also elsewhere on the board
/OOUT_Q: K501.5, K517.3; also elsewhere on the board
/OOUT_R: K502.5, K518.3; also elsewhere on the board
/OOUT_S: K503.5, K519.3; also elsewhere on the board
/OOUT_T: K504.5, K520.3; also elsewhere on the board
/OOUT_U: K505.5, K521.3; also elsewhere on the board
/OOUT_V: K506.5, K522.3; also elsewhere on the board
/OOUT_W: K507.5, K523.3; also elsewhere on the board
/OOUT_X: K508.5, K524.3; also elsewhere on the board
/OOUT_Y: K509.5, K525.3; also elsewhere on the board
/OOUT_Z: K510.5, K526.3; also elsewhere on the board
/R4_A: K501.9; also elsewhere on the board
/R4_B: K502.9; also elsewhere on the board
/R4_C: K503.9; also elsewhere on the board
/R4_D: K504.9; also elsewhere on the board
/R4_E: K505.9; also elsewhere on the board
/R4_F: K506.9; also elsewhere on the board
/R4_G: K507.9; also elsewhere on the board
/R4_H: K508.9; also elsewhere on the board
/R4_I: K509.9; also elsewhere on the board
/R4_J: K510.9; also elsewhere on the board
/R4_K: K511.9; also elsewhere on the board
/R4_L: K512.9; also elsewhere on the board
/R4_M: K513.9; also elsewhere on the board
/R4_N: K514.9; also elsewhere on the board
/R4_O: K515.9; also elsewhere on the board
/R4_P: K516.9; also elsewhere on the board
/R4_Q: K517.9; also elsewhere on the board
/R4_R: K518.9; also elsewhere on the board
/R4_S: K519.9; also elsewhere on the board
/R4_T: K520.9; also elsewhere on the board
/R4_U: K521.9; also elsewhere on the board
/R4_V: K522.9; also elsewhere on the board
/R4_W: K523.9; also elsewhere on the board
/R4_X: K524.9; also elsewhere on the board
/R4_Y: K525.9; also elsewhere on the board
/R4_Z: K526.9; also elsewhere on the board
/ROUT_A: K501.10, K517.8; also elsewhere on the board
/ROUT_B: K502.10, K518.8; also elsewhere on the board
/ROUT_C: K503.10, K519.8; also elsewhere on the board
/ROUT_D: K504.10, K520.8; also elsewhere on the board
/ROUT_E: K505.10, K521.8; also elsewhere on the board
/ROUT_F: K506.10, K522.8; also elsewhere on the board
/ROUT_G: K507.10, K523.8; also elsewhere on the board
/ROUT_H: K508.10, K524.8; also elsewhere on the board
/ROUT_I: K509.10, K525.8; also elsewhere on the board
/ROUT_J: K510.10, K526.8; also elsewhere on the board
/ROUT_K: K501.8, K511.10; also elsewhere on the board
/ROUT_L: K502.8, K512.10; also elsewhere on the board
/ROUT_M: K503.8, K513.10; also elsewhere on the board
/ROUT_N: K504.8, K514.10; also elsewhere on the board
/ROUT_O: K505.8, K515.10; also elsewhere on the board
/ROUT_P: K506.8, K516.10; also elsewhere on the board
/ROUT_Q: K507.8, K517.10; also elsewhere on the board
/ROUT_R: K508.8, K518.10; also elsewhere on the board
/ROUT_S: K509.8, K519.10; also elsewhere on the board
/ROUT_T: K510.8, K520.10; also elsewhere on the board
/ROUT_U: K511.8, K521.10; also elsewhere on the board
/ROUT_V: K512.8, K522.10; also elsewhere on the board
/ROUT_W: K513.8, K523.10; also elsewhere on the board
/ROUT_X: K514.8, K524.10; also elsewhere on the board
/ROUT_Y: K515.8, K525.10; also elsewhere on the board
/ROUT_Z: K516.8, K526.10; also elsewhere on the board
/STAGE_16/IND: DL5.2 (A), R5.2

Notes on the sheet:
Stage 5 of 5: control bit 4 (weight 16). Outbound pole 1: COM=OIN_i, NC->OOUT_i, NO->OOUT_(i+16 mod 26). Return pole 2: COM=RIN_i, NC->ROUT_i, NO->ROUT_(i-16 mod 26). CTRL = 24 V stage drive, GND = 0 V. Coil pin 1 = +, pin 12 = - (verify polarity).

Board: 4 copper layers, 281 parts (0 on the bottom side), 324 nets, no tracks yet.

## KiCad design hardware/relay/wiring-cards/cart_II.kicad_pcb

Schematic: cart_II.kicad_sch, Relay rotor cartridge: rotor II

Parts:
DT1: DETECT 1; CartridgePad_D1.8
DT2: DETECT 2; CartridgePad_D1.8
OI1: PAD OI A; CartridgePad_D1.8
OI2: PAD OI B; CartridgePad_D1.8
OI3: PAD OI C; CartridgePad_D1.8
OI4: PAD OI D; CartridgePad_D1.8
OI5: PAD OI E; CartridgePad_D1.8
OI6: PAD OI F; CartridgePad_D1.8
OI7: PAD OI G; CartridgePad_D1.8
OI8: PAD OI H; CartridgePad_D1.8
OI9: PAD OI I; CartridgePad_D1.8
OI10: PAD OI J; CartridgePad_D1.8
OI11: PAD OI K; CartridgePad_D1.8
OI12: PAD OI L; CartridgePad_D1.8
OI13: PAD OI M; CartridgePad_D1.8
OI14: PAD OI N; CartridgePad_D1.8
OI15: PAD OI O; CartridgePad_D1.8
OI16: PAD OI P; CartridgePad_D1.8
OI17: PAD OI Q; CartridgePad_D1.8
OI18: PAD OI R; CartridgePad_D1.8
OI19: PAD OI S; CartridgePad_D1.8
OI20: PAD OI T; CartridgePad_D1.8
OI21: PAD OI U; CartridgePad_D1.8
OI22: PAD OI V; CartridgePad_D1.8
OI23: PAD OI W; CartridgePad_D1.8
OI24: PAD OI X; CartridgePad_D1.8
OI25: PAD OI Y; CartridgePad_D1.8
OI26: PAD OI Z; CartridgePad_D1.8
OO1: PAD OO A; CartridgePad_D1.8
OO2: PAD OO B; CartridgePad_D1.8
OO3: PAD OO C; CartridgePad_D1.8
OO4: PAD OO D; CartridgePad_D1.8
OO5: PAD OO E; CartridgePad_D1.8
OO6: PAD OO F; CartridgePad_D1.8
OO7: PAD OO G; CartridgePad_D1.8
OO8: PAD OO H; CartridgePad_D1.8
OO9: PAD OO I; CartridgePad_D1.8
OO10: PAD OO J; CartridgePad_D1.8
OO11: PAD OO K; CartridgePad_D1.8
OO12: PAD OO L; CartridgePad_D1.8
OO13: PAD OO M; CartridgePad_D1.8
OO14: PAD OO N; CartridgePad_D1.8
OO15: PAD OO O; CartridgePad_D1.8
OO16: PAD OO P; CartridgePad_D1.8
OO17: PAD OO Q; CartridgePad_D1.8
OO18: PAD OO R; CartridgePad_D1.8
OO19: PAD OO S; CartridgePad_D1.8
OO20: PAD OO T; CartridgePad_D1.8
OO21: PAD OO U; CartridgePad_D1.8
OO22: PAD OO V; CartridgePad_D1.8
OO23: PAD OO W; CartridgePad_D1.8
OO24: PAD OO X; CartridgePad_D1.8
OO25: PAD OO Y; CartridgePad_D1.8
OO26: PAD OO Z; CartridgePad_D1.8
RI1: PAD RI A; CartridgePad_D1.8
RI2: PAD RI B; CartridgePad_D1.8
RI3: PAD RI C; CartridgePad_D1.8
RI4: PAD RI D; CartridgePad_D1.8
RI5: PAD RI E; CartridgePad_D1.8
RI6: PAD RI F; CartridgePad_D1.8
RI7: PAD RI G; CartridgePad_D1.8
RI8: PAD RI H; CartridgePad_D1.8
RI9: PAD RI I; CartridgePad_D1.8
RI10: PAD RI J; CartridgePad_D1.8
RI11: PAD RI K; CartridgePad_D1.8
RI12: PAD RI L; CartridgePad_D1.8
RI13: PAD RI M; CartridgePad_D1.8
RI14: PAD RI N; CartridgePad_D1.8
RI15: PAD RI O; CartridgePad_D1.8
RI16: PAD RI P; CartridgePad_D1.8
RI17: PAD RI Q; CartridgePad_D1.8
RI18: PAD RI R; CartridgePad_D1.8
RI19: PAD RI S; CartridgePad_D1.8
RI20: PAD RI T; CartridgePad_D1.8
RI21: PAD RI U; CartridgePad_D1.8
RI22: PAD RI V; CartridgePad_D1.8
RI23: PAD RI W; CartridgePad_D1.8
RI24: PAD RI X; CartridgePad_D1.8
RI25: PAD RI Y; CartridgePad_D1.8
RI26: PAD RI Z; CartridgePad_D1.8
RO1: PAD RO A; CartridgePad_D1.8
RO2: PAD RO B; CartridgePad_D1.8
RO3: PAD RO C; CartridgePad_D1.8
RO4: PAD RO D; CartridgePad_D1.8
RO5: PAD RO E; CartridgePad_D1.8
RO6: PAD RO F; CartridgePad_D1.8
RO7: PAD RO G; CartridgePad_D1.8
RO8: PAD RO H; CartridgePad_D1.8
RO9: PAD RO I; CartridgePad_D1.8
RO10: PAD RO J; CartridgePad_D1.8
RO11: PAD RO K; CartridgePad_D1.8
RO12: PAD RO L; CartridgePad_D1.8
RO13: PAD RO M; CartridgePad_D1.8
RO14: PAD RO N; CartridgePad_D1.8
RO15: PAD RO O; CartridgePad_D1.8
RO16: PAD RO P; CartridgePad_D1.8
RO17: PAD RO Q; CartridgePad_D1.8
RO18: PAD RO R; CartridgePad_D1.8
RO19: PAD RO S; CartridgePad_D1.8
RO20: PAD RO T; CartridgePad_D1.8
RO21: PAD RO U; CartridgePad_D1.8
RO22: PAD RO V; CartridgePad_D1.8
RO23: PAD RO W; CartridgePad_D1.8
RO24: PAD RO X; CartridgePad_D1.8
RO25: PAD RO Y; CartridgePad_D1.8
RO26: PAD RO Z; CartridgePad_D1.8

Connections:
/DET: DT1.1, DT2.1
/OW_AA: OI1.1, OO1.1
/OW_BJ: OI2.1, OO10.1
/OW_CD: OI3.1, OO4.1
/OW_DK: OI4.1, OO11.1
/OW_ES: OI5.1, OO19.1
/OW_FI: OI6.1, OO9.1
/OW_GR: OI7.1, OO18.1
/OW_HU: OI8.1, OO21.1
/OW_IX: OI9.1, OO24.1
/OW_JB: OI10.1, OO2.1
/OW_KL: OI11.1, OO12.1
/OW_LH: OI12.1, OO8.1
/OW_MW: OI13.1, OO23.1
/OW_NT: OI14.1, OO20.1
/OW_OM: OI15.1, OO13.1
/OW_PC: OI16.1, OO3.1
/OW_QQ: OI17.1, OO17.1
/OW_RG: OI18.1, OO7.1
/OW_SZ: OI19.1, OO26.1
/OW_TN: OI20.1, OO14.1
/OW_UP: OI21.1, OO16.1
/OW_VY: OI22.1, OO25.1
/OW_WF: OI23.1, OO6.1
/OW_XV: OI24.1, OO22.1
/OW_YO: OI25.1, OO15.1
/OW_ZE: OI26.1, OO5.1
/RW_AA: RI1.1, RO1.1
/RW_BJ: RI2.1, RO10.1
/RW_CP: RI3.1, RO16.1
/RW_DC: RI4.1, RO3.1
/RW_EZ: RI5.1, RO26.1
/RW_FW: RI6.1, RO23.1
/RW_GR: RI7.1, RO18.1
/RW_HL: RI8.1, RO12.1
/RW_IF: RI9.1, RO6.1
/RW_JB: RI10.1, RO2.1
/RW_KD: RI11.1, RO4.1
/RW_LK: RI12.1, RO11.1
/RW_MO: RI13.1, RO15.1
/RW_NT: RI14.1, RO20.1
/RW_OY: RI15.1, RO25.1
/RW_PU: RI16.1, RO21.1
/RW_QQ: RI17.1, RO17.1
/RW_RG: RI18.1, RO7.1
/RW_SE: RI19.1, RO5.1
/RW_TN: RI20.1, RO14.1
/RW_UH: RI21.1, RO8.1
/RW_VX: RI22.1, RO24.1
/RW_WM: RI23.1, RO13.1
/RW_XI: RI24.1, RO9.1
/RW_YV: RI25.1, RO22.1
/RW_ZS: RI26.1, RO19.1

Notes on the sheet:
OI = OUTBOUND_IN
OO = OUTBOUND_OUT
RO = RETURN_OUT
RI = RETURN_IN
ROTOR II cartridge. Passive: the same nets as the W card rotor_II (OW_<in><out>, RW_<in><out>). W = AJDKSIRUXBLHWTMCQGZNPYFVOE Winv = AJPCZWRLFBDKOTYUQGENHXMIVS Pads on the back side, facing the spring pins of the bay; the two keying holes are on the board (no net).

Board: 4 copper layers, 110 parts (106 on the bottom side), 53 nets, no tracks yet.

Other parts of the board:
K3: NPTH 3.05; NPTH_3.05mm
K4: NPTH 4.05; NPTH_4.05mm
NH1, NH2: NPTH 2.7; NPTH_2.7mm

## KiCad design hardware/relay/wiring-cards/reflector_B.kicad_pcb

Schematic: reflector_B.kicad_sch, Relay reflector card U: reflector B

Parts:
H1, H2, H3, H4: M3_CHASSIS; MountingHole_3.2mm_M3_Pad
J2: RETURN_OUT; DSUB-37_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Ho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
J3: OUTBOUND_IN; DSUB-37_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Ho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

Connections:
/CHASSIS: H1.1, H2.1, H3.1, H4.1, J2.SH, J3.SH
/RF_AY: J2.25, J3.1
/RF_BR: J2.18, J3.2
/RF_CU: J2.21, J3.3
/RF_DH: J2.8, J3.4
/RF_EQ: J2.17, J3.5
/RF_FS: J2.19, J3.6
/RF_GL: J2.12, J3.7
/RF_HD: J2.4, J3.8
/RF_IP: J2.16, J3.9
/RF_JX: J2.24, J3.10
/RF_KN: J2.14, J3.11
/RF_LG: J2.7, J3.12
/RF_MO: J2.15, J3.13
/RF_NK: J2.11, J3.14
/RF_OM: J2.13, J3.15
/RF_PI: J2.9, J3.16
/RF_QE: J2.5, J3.17
/RF_RB: J2.2, J3.18
/RF_SF: J2.6, J3.19
/RF_TZ: J2.26, J3.20
/RF_UC: J2.3, J3.21
/RF_VW: J2.23, J3.22
/RF_WV: J2.22, J3.23
/RF_XJ: J2.10, J3.24
/RF_YA: J2.1, J3.25
/RF_ZT: J2.20, J3.26

Notes on the sheet:
REFLECTOR B card (U). Passive: the outbound end of the stack turns around here. R[A..Z] = YRUHQSLDPXNGOKMIEBFZCWVJAT (an involution without fixed points) J3 pin i+1 (outbound line i) is wired to J2 pin R[i]+1 (return line R[i]); net RF_<in><out>. Only two connectors: J3 at the shifter's J3 position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

Board: 2 copper layers, 6 parts (0 on the bottom side), 27 nets, no tracks yet.

## KiCad design hardware/relay/wiring-cards/reflector_C.kicad_pcb

Schematic: reflector_C.kicad_sch, Relay reflector card U: reflector C

Parts:
H1, H2, H3, H4: M3_CHASSIS; MountingHole_3.2mm_M3_Pad
J2: RETURN_OUT; DSUB-37_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Ho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
J3: OUTBOUND_IN; DSUB-37_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Ho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

Connections:
/CHASSIS: H1.1, H2.1, H3.1, H4.1, J2.SH, J3.SH
/RF_AF: J2.6, J3.1
/RF_BV: J2.22, J3.2
/RF_CP: J2.16, J3.3
/RF_DJ: J2.10, J3.4
/RF_EI: J2.9, J3.5
/RF_FA: J2.1, J3.6
/RF_GO: J2.15, J3.7
/RF_HY: J2.25, J3.8
/RF_IE: J2.5, J3.9
/RF_JD: J2.4, J3.10
/RF_KR: J2.18, J3.11
/RF_LZ: J2.26, J3.12
/RF_MX: J2.24, J3.13
/RF_NW: J2.23, J3.14
/RF_OG: J2.7, J3.15
/RF_PC: J2.3, J3.16
/RF_QT: J2.20, J3.17
/RF_RK: J2.11, J3.18
/RF_SU: J2.21, J3.19
/RF_TQ: J2.17, J3.20
/RF_US: J2.19, J3.21
/RF_VB: J2.2, J3.22
/RF_WN: J2.14, J3.23
/RF_XM: J2.13, J3.24
/RF_YH: J2.8, J3.25
/RF_ZL: J2.12, J3.26

Notes on the sheet:
REFLECTOR C card (U). Passive: the outbound end of the stack turns around here. R[A..Z] = FVPJIAOYEDRZXWGCTKUQSBNMHL (an involution without fixed points) J3 pin i+1 (outbound line i) is wired to J2 pin R[i]+1 (return line R[i]); net RF_<in><out>. Only two connectors: J3 at the shifter's J3 position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

Board: 2 copper layers, 6 parts (0 on the bottom side), 27 nets, no tracks yet.
